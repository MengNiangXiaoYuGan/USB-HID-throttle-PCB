# Repository MengNiangXiaoYuGan/USB-HID-throttle-PCB

File README.md:

# USB-HID-throttle-PCB

该仓库作为USB-HID-throttle项目的电路板仓库,仓库内文件夹结构如下

|

|\  ternel_box  //节流阀主体的电路板，用于进行信号转换和USB通信

|

|\  ternel_handel   //节流阀手柄的电路板，用于tdc，雷达俯仰轴和两个五向开关的连接

|

|-  .gitignore      //用于排除包含电路设计过程中的备份文件

|   

|-  firmware.bin    //编译好的固件

|

|-  LICENSE     //许可证文件

如果不打算使用源文件的话，可以直接下载releases中的压缩包，里面包含了两块电路板的gerber文件和动态bom单，以及关于为了下载程序需要对电路板进行应急处理

另外，为了制造具有完整功能的USB-HID节流阀，还需要制造外壳模型以及下载程序。
模型可以从以下仓库获得
https://github.com/MengNiangXiaoYuGan/USB-HID-throttle-model.git

程序源码可以在以下仓库获得，或者在电路板仓库中直接使用已经编译好的bin文件
https://github.com/MengNiangXiaoYuGan/USB-HID-throttle-program.git

祝，使用愉快，有问题请反馈，有闲心会看一下

## KiCad design ternel_handel/ternel_handel.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26: 100nf/50V; 0603_C
C10, C11: 100nf/50V; 0603_C; not fitted
J1, J2, J3: PH2.0-LS-3P; CONN-SMD_3P-P2.00_PH2.0-LT-3P
J4: PH2.0-LS-3P; CONN-SMD_3P-P2.00_PH2.0-LT-3P; not fitted
P1, P2, P3, P4: PH2.0-6P-LT; CONN-SMD_6P-P2.00_SHOU_2.0-6PLTDK
SW1, SW2: RKJXV1224005; 4AXIS_ROTATE-TH_RKJXV1224005
SW3, SW4: K1-1506SN-01; 5AXIS_SWITCH-SMD_K1-1506SN-01

Connections:
+3V3: C1.2, C2.2, C25.1, C26.2, P1.1, SW1.3 (A), SW1.4 (A), SW2.3 (A)
/BOTTOM-KEY: C5.1, J1.1, J1.3, P3.5
/MAD-FORW: C19.2, P3.2, SW4.3
/MAD-HAND: C17.2, P2.6, SW4.1
/MAD-KEY: C21.2, P3.4, SW4.6
/MAD-LEFT: C18.2, P3.1, SW4.2
/MAD-RIGHT: C20.2, P3.3, SW4.5
/MID-FORW: C14.2, P2.3, SW3.3
/MID-HAND: C12.2, P2.1, SW3.1
/MID-KEY: C16.2, P2.5, SW3.6
/MID-LEFT: C13.2, P2.2, SW3.2
/MID-RIGHT: C15.2, P2.4, SW3.5
/PINKEY-AHEAD: C6.1, J2.1, P3.6
/PINKEY-FOWORD: C7.1, J2.3, P4.1
/PINKEYKEY-AHEAD: C8.1, J3.1, P4.2
/PINKEYKEY-FOWORD: C9.1, J3.3, P4.3
/PINKEYKEYKEY-AHEAD: C10.1, J4.1, P4.4
/PINKEYKEYKEY-FOWORD: C11.1, J4.3, P4.5
/ROW-KEY1: C4.1, P1.6, SW2.c
/ROW-RV1: C24.2, P1.5, SW2.2 (DTA)
/TDC-KEY1: C3.1, P1.4, SW1.c
/TDC-RV1: C22.2, P1.2, SW1.2 (DTA)
/TDC-RV2: C23.2, P1.3, SW1.5 (DTA)
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.2, C26.1, J1.2, J1.4, J1.5, J2.2, J2.4, J2.5, J3.2, J3.4, J3.5, J4.2, J4.4, J4.5, P1.7, P1.8, P2.7, P2.8, P3.7, P3.8, P4.6, P4.7, P4.8, SW1.1 (B), SW1.6 (B), SW1.7 (GND), SW1.8 (GND), SW1.9 (GND), SW1.10 (GND), SW1.b, SW2.1 (B), SW2.6 (B), SW2.7 (GND), SW2.8 (GND), SW2.9 (GND), SW2.10 (GND), SW2.b, SW3.4, SW4.4

Notes on the sheet:
雷达俯仰
五向开关
TDC
小指开关
右面板按键拨杆

Board: 2 copper layers, 100.0 x 39.0 mm, 38 parts (4 on the bottom side), 24 nets.

## KiCad design ternel_box/ternel_box.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14: 100nf/50V; 0603_C
J1, J2, J3, J4, J5, J6, J7, J8: PH2.0-LS-3P; CONN-SMD_3P-P2.00_PH2.0-LT-3P
P1, P2, P3, P4: PH2.0-6P-LT; CONN-SMD_6P-P2.00_SHOU_2.0-6PLTDK

Connections:
+3V3: C1.1, C14.1, J1.1, P1.1; also elsewhere on the board
/BANKEY-1-1: C6.1, J2.1; also elsewhere on the board
/BANKEY-1-2: C2.1, J2.3; also elsewhere on the board
/BANKEY-2-1: C7.1, J3.1; also elsewhere on the board
/BANKEY-2-2: C3.1, J3.3; also elsewhere on the board
/BANKEY-3-1: C8.1, J4.1; also elsewhere on the board
/BANKEY-3-2: C4.1, J4.3; also elsewhere on the board
/BANKEY-4-1: C11.1, J7.1; also elsewhere on the board
/BANKEY-4-2: C5.1, J7.3; also elsewhere on the board
/BANKEY-5-1: C12.1, J8.1; also elsewhere on the board
/BANKEY-5-2: C13.1, J8.3; also elsewhere on the board
/BOTTOM-KEY: P3.5; also elsewhere on the board
/MAD-FORW: P3.2; also elsewhere on the board
/MAD-HAND: P2.6; also elsewhere on the board
/MAD-KEY: P3.4; also elsewhere on the board
/MAD-LEFT: P3.1; also elsewhere on the board
/MAD-RIGHT: P3.3; also elsewhere on the board
/MID-FORW: P2.3; also elsewhere on the board
/MID-HAND: P2.1; also elsewhere on the board
/MID-KEY: P2.5; also elsewhere on the board
/MID-LEFT: P2.2; also elsewhere on the board
/MID-RIGHT: P2.4; also elsewhere on the board
/PENKEY-1-1: C9.1, J5.1, J5.3; also elsewhere on the board
/PENKEY-2-1: C10.1, J6.1, J6.3; also elsewhere on the board
/PINKEY-AHEAD: P3.6; also elsewhere on the board
/PINKEY-FOWORD: P4.1; also elsewhere on the board
/PINKEYKEY-AHEAD: P4.2; also elsewhere on the board
/PINKEYKEY-FOWORD: P4.3; also elsewhere on the board
/PINKEYKEYKEY-AHEAD: P4.4; also elsewhere on the board
/PINKEYKEYKEY-FOWORD: P4.5; also elsewhere on the board
/ROW-KEY1: P1.6; also elsewhere on the board
/ROW-RV1: P1.5; also elsewhere on the board
/RV-TERNEL: J1.2; also elsewhere on the board
/TDC-KEY1: P1.4; also elsewhere on the board
/TDC-RV1: P1.2; also elsewhere on the board
/TDC-RV2: P1.3; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, J1.3, J1.4, J1.5, J2.2, J2.4, J2.5, J3.2, J3.4, J3.5, J4.2, J4.4, J4.5, J5.2, J5.4, J5.5, J6.2, J6.4, J6.5, J7.2, J7.4, J7.5, J8.2, J8.4, J8.5, P1.7, P1.8, P2.7, P2.8, P3.7, P3.8, P4.6, P4.7, P4.8; also elsewhere on the board

Notes on the sheet:
底座按键-接线口
油门手柄 接线口

Parts:
C15, C24: 47uf/50V; 1206_C
C16, C20: 47uf/50V; 1206_C; not fitted
C17, C21, C23: 100nf/50V; 0603_C
C18, C19, C22: 100nf/50V; 0603_C; not fitted
L1: 6.8uh/2.5A; IND-SMD_L4.4-W4.2
R1: 100K; 0603_R
R2: 22K; 0603_R
U1: AMS1117; SOT-223; not fitted
U2: MT2492; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR

Connections:
+3V3: C15.1, C17.1, C18.1, C20.1, C22.1, L1.1, R1.2, U1.2 (Vout); also elsewhere on the board
+5V: C16.1, C19.1, C23.1, C24.1, U1.3 (Vin), U2.4 (EN), U2.5 (IN); also elsewhere on the board
/电源模块/SW: C21.2, L1.2, U2.6 (SW)
GND: C15.2, C16.2, C17.2, C19.2, C20.2, C22.2, C23.2, C24.2, R2.1, U1.1 (GND), U2.2 (GND); also elsewhere on the board
unnamed: C21.1, U2.1 (BS)
unnamed: C18.2, R1.1, R2.2, U2.3 (FB)

Notes on the sheet:
12-3.3DCDC

Parts:
R6, R7, R8, R9, R10, R15, R16, R17, R18, R19, R20, R21, R28, R29, R30, R31, R34, R35, R36, R40, R41, R44, R46, R47, R50, R51, R53, R54, R58, R59, R60, R64, R66: 22R; 0603_R
R11, R12, R13, R14, R22, R23, R24, R25, R26, R27, R32, R33, R37, R38, R39, R42, R43, R45, R48, R49, R52, R55, R56, R57, R61, R62, R63, R65, R67: 10K; 0603_R
R68, R70: 22R; 0603_R; not fitted
R69, R71: 10K; 0603_R; not fitted

Connections:
+3V3: R11.1, R12.1, R13.1, R14.1, R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, R32.1, R33.1, R37.1, R38.1, R39.1, R42.1, R43.1, R45.1, R48.1, R49.1, R52.1, R55.1, R56.1, R57.1, R61.1, R62.1, R63.1, R65.1, R67.1, R69.1, R71.1; also elsewhere on the board
/BANKEY-1-1: R15.2, R22.2; also elsewhere on the board
/BANKEY-1-2: R16.2, R23.2; also elsewhere on the board
/BANKEY-2-1: R17.2, R24.2; also elsewhere on the board
/BANKEY-2-2: R18.2, R25.2; also elsewhere on the board
/BANKEY-3-1: R19.2, R26.2; also elsewhere on the board
/BANKEY-3-2: R20.2, R27.2; also elsewhere on the board
/BANKEY-4-1: R8.2, R13.2; also elsewhere on the board
/BANKEY-4-2: R9.2, R14.2; also elsewhere on the board
/BANKEY-5-1: R64.2, R65.2; also elsewhere on the board
/BANKEY-5-2: R66.2, R67.2; also elsewhere on the board
/BOTTOM-KEY: R44.2, R45.2; also elsewhere on the board
/MAD-FORW: R30.2, R32.2; also elsewhere on the board
/MAD-HAND: R6.2, R11.2; also elsewhere on the board
/MAD-KEY: R36.2, R39.2; also elsewhere on the board
/MAD-LEFT: R7.2, R12.2; also elsewhere on the board
/MAD-RIGHT: R31.2, R33.2; also elsewhere on the board
/MID-FORW: R53.2, R56.2; also elsewhere on the board
/MID-HAND: R46.2, R48.2; also elsewhere on the board
/MID-KEY: R58.2, R61.2; also elsewhere on the board
/MID-LEFT: R47.2, R49.2; also elsewhere on the board
/MID-RIGHT: R54.2, R57.2; also elsewhere on the board
/PENKEY-1-1: R34.2, R37.2; also elsewhere on the board
/PENKEY-2-1: R35.2, R38.2; also elsewhere on the board
/PINKEY-AHEAD: R50.2, R52.2; also elsewhere on the board
/PINKEY-FOWORD: R51.2, R55.2; also elsewhere on the board
/PINKEYKEY-AHEAD: R59.2, R62.2; also elsewhere on the board
/PINKEYKEY-FOWORD: R60.2, R63.2; also elsewhere on the board
/PINKEYKEYKEY-AHEAD: R68.2, R69.2; also elsewhere on the board
/PINKEYKEYKEY-FOWORD: R70.2, R71.2; also elsewhere on the board
/ROW-KEY1: R41.2, R43.2; also elsewhere on the board
/ROW-RV1: R28.1; also elsewhere on the board
/RV-TERNEL: R29.1; also elsewhere on the board
/TDC-KEY1: R40.2, R42.2; also elsewhere on the board
/TDC-RV1: R10.1; also elsewhere on the board
/TDC-RV2: R21.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/ADC0: R10.2; also elsewhere on the board
/中间件-输入信号整型-上下拉/ADC1: R21.2; also elsewhere on the board
/中间件-输入信号整型-上下拉/ADC2: R28.2; also elsewhere on the board
/中间件-输入信号整型-上下拉/ADC3: R29.2; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY1: R47.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY2: R53.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY3: R54.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY4: R58.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY5: R6.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY6: R7.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY8: R31.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY9: R36.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY10: R44.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY11: R50.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY12: R51.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY13: R59.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY14: R60.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY17: R19.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY18: R20.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY19: R34.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY20: R35.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY21: R8.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY22: R9.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY23: R64.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY24: R66.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY25: R40.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY26: R41.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY27: R46.1; also elsewhere on the board
/主控板/BOOT1: R30.1; also elsewhere on the board
/主控板/DOWM-RX: R16.1; also elsewhere on the board
/主控板/DOWM-TX: R15.1; also elsewhere on the board
/主控板/SYS-SWCLK: R18.1; also elsewhere on the board
/主控板/SYS-SWDIO: R17.1; also elsewhere on the board

Notes on the sheet:
KEY16,KEY16相连的22R电阻 需要在下载之后再进行焊接， 否则信号波形无法达到通讯要求 会导致串口通信不上 R15 R16

Parts:
C25, C26, C30, C31, C32: 100nf/50V; 0603_C
C27, C28: 22pf/50V; 0603_C
C29: 10uf/10V; 0603_C
C33: 4.7uf/16V; 0603_C
D1: SMF6.5CA; SOD-123
K1: bottom; TACTILE_SWITCH_SMD_6.0X3.5MM; not fitted
P5: PH2.0-4P; CONN-SMD_PH2.0-4P-LT
P6, P9: XH2.54-1*7P; 2.54PIN-4P; not fitted
P7, P8: XH2.54-1*7P; 2.54PIN-2P; not fitted
R3, R4: 22R; 0603_R
R5, R73: 10K; 0603_R
R72: 1.5K; 0603_R
U3: STM32F103C8T6; LQFP-48
X1: 3225-8Mhz; OSC-SMD_4P-L3.2-W2.5-BL

Connections:
+3V3: C29.1, C30.1, C31.1, C32.1, C33.1, P6.4, P8.1, P9.4, R5.1, R72.2, U3.1 (VBAT), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD); also elsewhere on the board
+5V: C25.2, D1.2, P5.1; also elsewhere on the board
/中间件-输入信号整型-上下拉/ADC0: U3.10 (PA0); also elsewhere on the board
/中间件-输入信号整型-上下拉/ADC1: U3.11 (PA1); also elsewhere on the board
/中间件-输入信号整型-上下拉/ADC2: U3.12 (PA2); also elsewhere on the board
/中间件-输入信号整型-上下拉/ADC3: U3.13 (PA3); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY1: U3.14 (PA4); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY2: U3.15 (PA5); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY3: U3.16 (PA6); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY4: U3.17 (PA7); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY5: U3.18 (PB0); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY6: U3.19 (PB1); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY8: U3.21 (PB10); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY9: U3.22 (PB11); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY10: U3.25 (PB12); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY11: U3.26 (PB13); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY12: U3.27 (PB14); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY13: U3.28 (PB15); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY14: U3.29 (PA8); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY17: U3.38 (PA15); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY18: U3.39 (PB3); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY19: U3.40 (PB4); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY20: U3.41 (PB5); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY21: U3.42 (PB6); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY22: U3.43 (PB7); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY23: U3.45 (PB8); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY24: U3.46 (PB9); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY25: U3.2 (PC13); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY26: U3.3 (PC14); also elsewhere on the board
/中间件-输入信号整型-上下拉/KEY27: U3.4 (PC15); also elsewhere on the board
/主控板/BOOT0: P8.2, R73.1, U3.44 (BOOT0)
/主控板/BOOT1: P7.2, U3.20 (PB2); also elsewhere on the board
/主控板/DOWM-RX: P6.2, U3.31 (PA10); also elsewhere on the board
/主控板/DOWM-TX: P6.3, U3.30 (PA9); also elsewhere on the board
/主控板/SYS-SWCLK: P9.2, U3.37 (PA14); also elsewhere on the board
/主控板/SYS-SWDIO: P9.3, U3.34 (PA13); also elsewhere on the board
/主控板/USB-D+: R4.2, U3.33 (PA12)
/主控板/USB-D-: R3.2, U3.32 (PA11)
/主控板/USBTOU-D+: P5.3, R4.1, R72.1
/主控板/USBTOU-D-: P5.2, R3.1
GND: C25.1, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, D1.1, K1.2, P5.4, P5.5, P5.6, P6.1, P7.1, P9.1, R73.2, U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), X1.2 (GND), X1.4 (GND); also elsewhere on the board
unnamed: C26.1, K1.1, R5.2, U3.7 (NRST)
unnamed: C27.1, U3.5 (PD0), X1.1 (OSC1)
unnamed: C28.1, U3.6 (PD1), X1.3 (OSC2)

Notes on the sheet:
P6为下载口， 需要使用usb转ttl进行下载， P7在下载前需要短接， P8在下载前也需要短接 然后下载， 下载完成后去掉P7的焊线， 即可正常使用
P9-也就是调试口， 在使用前需要将连接外设的22R电阻去掉， 否则会连接不上
主控部分
调试口
USB接口 差分90欧

Board: 2 copper layers, 60.0 x 100.0 mm, 130 parts (0 on the bottom side), 82 nets.

## Commit log

2025-05-29 初始化完成
2025-05-29 忘记放程序了
2025-05-29 修改错误
